## package/detector/Config.in
```kconfig
config BR2_PACKAGE_DETECTOR
    bool "detector"
    help
      This is the detector application for the Beaglebone Black.
```
